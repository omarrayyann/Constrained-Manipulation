Commit message: Update

File: urdf/iiwa.urdf (robot description, URDF)
Before this commit: robot KUKAiiwa14, 9 links, 8 joints
Links:
- removed link contact
Joints:
- removed joint END
